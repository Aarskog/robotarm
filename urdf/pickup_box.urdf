Commit message: Started with computer vision

File: urdf/pickup_box.urdf (robot description, URDF)
Before this commit: robot yes3, 1 links, 0 joints
Links:
- removed link base_link
- added link box_link, mass 0.1; collision box size=0.04 0.04 0.04; visual box size=0.04 0.04 0.04
